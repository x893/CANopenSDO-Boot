# Keil uVision project firmware-v4.uvprojx, settings and files
target sdo-bootloader (6240000::V6.24::ARMCLANG)
  device: -AT32F415CCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NO_USE_WDT AT32F415CCT7 USE_STDPERIPH_DRIVER
  c include: .\core;.\drivers;.\boards;..\od;..\canopen_at32;..\canopennode;..\canopennode\301;..\at32_fwlib\libraries\drivers\inc;..\at32_fwlib\libraries\cmsis\cm4\core_support;..\at32_fwlib\libraries\cmsis\cm4\device_support;..\at32_fwlib\middlewares\usb_drivers\inc;..\at32_fwlib\middlewares\usbd_class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group AT32F415_Firmware_Library
    ../at32_fwlib/libraries/drivers/src/: at32f415_crm.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_can.c at32f415_dma.c at32f415_adc.c at32f415_spi.c at32f415_debug.c at32f415_wwdt.c at32f415_wdt.c at32f415_crc.c at32f415_i2c.c
  group src
    ./startup/mdk/: startup_at32f415.s
    ./core/: system_at32f415.c at32f415_int.c main.c
  group board
    ./boards/: boards.h boards.c
  group CANopenNode_AT32
    ../canopen_at32/: CO_app_AT32.c CO_driver_AT32.c CO_driver_target.h OD.h
    ../od/: OD.c
  group CANopenNode
    ../canopennode/: CANopen.c
  group CANopenNode/301
    ../canopennode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
  group CANopenNode/303
    ../canopennode/303/: CO_LEDs.c
  group CANopenNode/304
    ../canopennode/304/: CO_GFC.c CO_SRDO.c
  group CANopenNode/305
    ../canopennode/305/: CO_LSSmaster.c CO_LSSslave.c
  group CANopenNode/309
    ../canopennode/309/: CO_gateway_ascii.c
  group CANopenNode/storage
    ../canopennode/storage/: CO_storage.c
